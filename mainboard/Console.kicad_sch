File: mainboard/Console.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: PCB rework
Other:
- added sheet Cassette (Cassette.kicad_sch)
