File: mainboard/Console.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: unicorn work
Other:
- added sheet Onboard-banked-rom (onboardrom.kicad_sch)
